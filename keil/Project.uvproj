# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\;..\os;..\bsp;..\obj;..\app;..\config
  asm include: ..\;..\os;..\bsp;..\obj;..\app
  group main
    ../: main.c
  group os
    ../os/: os.c os_queue.c
  group bsp
    ../bsp/: bsp_key.c bsp_led.c bsp_timer0.c
  group obj
    ../obj/: key_obj.c led_obj.c
  group app
    ../app/: app_key.c app_led.c
